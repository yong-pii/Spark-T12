# Keil uVision project Spark-T12.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: versions-V1.11 +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: .\SRC;.\STClibrary;.\SRC\IIC;.\SRC\SC7A20TR
  group Source Group 1
    ./: main.c
  group device
    ./SRC/IIC/: IIC.c
    ./SRC/SC7A20TR/: SC7A20TR.c
    ./SRC/: beep.c Ch224d.c Interface.c key.c oled.c NTC.c sleep.c Spark_T12_PID.c
  group stc_lbr
    ./STClibrary/: ADC.c delay.c GPIO.c timer.c EEPROM.c
  group Readme
    ./: Readme.txt
