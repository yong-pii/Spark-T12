# Keil uVision project Spark-T12.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: versions-V1.11 +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: .\SRC;.\STClibrary
  group Source Group 1
    ./: main.c
    ./SRC/: oled.c beep.c key.c Ch224d.c Interface.c sleep.c Spark_T12_PID.c
    ./STClibrary/: ADC.c delay.c EEPROM.c GPIO.c PWM.C timer.c
  group Readme
    ./: Readme.txt
