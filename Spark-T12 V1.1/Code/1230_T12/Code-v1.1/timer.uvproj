# Keil uVision project timer.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: timer +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\SRC
  group Source Group 1
    ./: main.c GPIO.c delay.c UART.C timer.c ADC.c EEPROM.c PWM.C Spark_T12_PID.c sleep.c
    ./SRC/: oled.c beep.c key.c Ch224d.c Interface.c
  group Readme
    ./: Readme.txt
